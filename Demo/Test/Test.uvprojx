# Keil uVision project Test.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./Source-Codes/: gpio.c i2c.c main.c stm32f1xx_hal.c stm32f1xx_hal_msp.c stm32f1xx_hal_rcc.c stm32f1xx_it.c system_stm32f1xx.c gpio.h i2c.h main.h PAJ7620U2.h stm32f1xx.h stm32f1xx_hal.h stm32f1xx_hal_conf.h stm32f1xx_hal_def.h stm32f1xx_hal_rcc.h stm32f1xx_it.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
